# Keil uVision project Lion.uvproj, settings and files
target Lion (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: lion_frontier
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: ..\tools\EXEC .\obj\lion_frontier.bin ..\tools\lion_frontier.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: _USER_DEBUG
  c misc: --diag_suppress=1081
  c include: ..\..\include;..\driver\include;..\include\f1c100s;..\include;..\..\..\..\user_inc;..\..\..\..\lib;..\..\..\..\lib\UI;..\..\..\..\lib\FATFS\src;..\..\..\..\lib\FATFS\src\option;..\..\..\..\lib\FATFS\exfuns;..\..\..\..\lib\PICTURE;..\..\..\..\lib\FLASH;..\..\..\..\lib\TOUCH;..\..\..\..\lib\TEXT;..\..\..\..\lib\crypto;..\..\..\..\lib\FreeModbus_Slave_Master_v16\port;..\..\..\..\lib\FreeModbus_Slave_Master_v16\modbus\rtu;..\..\..\..\lib\USB;..\..\..\..\lib\ComPort;..\..\..\..\std_lib\include;..\..\..\..\lib\Mp3Lib\pub;..\..\..\..\lib\FreeRTOS-Kernel\include;..\..\..\..\lib\FreeRTOS-Kernel\user_define;..\..\..\..\lib\FreeRTOS-Kernel\portable\RVDS\ARM926ejs;..\..\..\..\hal\include;..\port\include;..\..\..\..\lib\music_library
  memory RVCT1: ROM 0x0 size 0x4000
  memory RVCT4: ROM 0x80000000 size 0x10000
  memory RVCT6: RAM 0x4000 size 0x4000
  memory RVCT9: RAM 0x80010000 size 0xffffffff
  scatter file: .\Script\MTF.sct
  link misc: --entry 0x80000000
  group MDK_project_src
    ./src/: standalone.c vectors1.s sys_start.s initial.c
  group hardware_src
    ../driver/: wdog-f1c100s.c usb_phy.c uart-16550.c timer_f1c100s.c sys_tvd.c sys_TPAdc.c sys_sd.c sys_defe.c sys_audio.c spi-f1c100s.c gpio-f1c100s.c reset-f1c100s.c pwm-f1c100s.c irq_misc.c fb-f1c100s.c clk-f1c100s-pll.c
    ../: sys-uart.c sys-spi-flash.c sys-mmu.c sys-dram.c sys-clock.c delay.c exception.c
    ../../lib/: arm32.c
    ../../../../std_lib/: malloc.c
  group user_src
    ../../../../user_src/: cJSON.c cJSON_extend.c licence.c main.c MTF_HMI.c TestBoard.c Sagittarius_global.c file_type.c Sagittarius_timer.c
  group app_lib
    ../../../../lib/: dma.c
    ../../../../lib/FATFS/src/: diskio.c ff.c
    ../../../../lib/FATFS/src/option/: cc936.c
    ../../../../lib/PICTURE/: bmp.c gif.c lodepng.c piclib.c
    ../../../../lib/FLASH/: w25qxx.c
    ../../../../lib/TOUCH/: touch.c gt9147.c ctiic.c ts_calibrate_common.c
    ../../../../lib/TEXT/: text.c text_rect.c font.c
    ../../../../lib/UI/: UI_engine.c lcd.c
    ../../../../lib/crypto/: crc32.c sha256.c
    ../../../../lib/ComPort/: dgus2Com.c ComPort.c MTF_ComProtocol.c T5UIC2_agreement.c
    ../../../../lib/FreeModbus_Slave_Master_v16/modbus/rtu/: mbcrc.c
    ../../../../lib/USB/: usb_cdc.c usb_desc.c usb_dev.c
    ../../../../lib/music_library/: music_play.c
  group mp3_lib
    ../../../../lib/Mp3Lib/: mp3_play.c mp3dec.c mp3tabs.c
    ../../../../lib/Mp3Lib/real/arm/: asmmisc.S asmpoly_thumb2.S
    ../../../../lib/Mp3Lib/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
  group FreeRTOS
    ../../../../lib/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../../../../lib/FreeRTOS-Kernel/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c croutine.c
    ../../../../lib/FreeRTOS-Kernel/portable/RVDS/ARM926ejs/: port.c portASM.s
  group hal_extend
    ../../../../hal/: MTF_io.c file_operate.c beep.c
  group hal_port
    ../port/: audio_port.c framebuffer_port.c GPIO_port.c PWM_port.c ROM_port.c timer_port.c touch_port.c uart_port.c
